## boards/shields/noboard/Kconfig.defconfig
```kconfig
if SHIELD_NOBOARD

config ZMK_KEYBOARD_NAME
    default "noboard"

endif # SHIELD_NOBOARD
```
